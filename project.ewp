# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: libraries\HAL_Drivers\config; rt-thread\include; libraries\HAL_Drivers; packages\bmi160_bmx160-latest\libraries; packages\bmi160_bmx160-latest; rt-thread\libcpu\arm\cortex-m4; libraries\STM32F4xx_HAL\CMSIS\Include; rt-thread\components\finsh; .; applications; rt-thread\components\drivers\include; board; libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; board\CubeMX_Config\Inc; rt-thread\components\utilities\ulog; packages\mpu6xxx-latest\inc; rt-thread\libcpu\arm\common; libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; rt-thread\components\drivers\sensors
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: communicate.c IMU.c main.c sensor_thread.c
  group bmi160
    packages/bmi160_bmx160-latest/libraries/: bmi160.c bmm150.c
    packages/bmi160_bmx160-latest/: sensor_bosch_bmx160.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/: board.c drv_led.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_soft_i2c.c drv_usart.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f411xe.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
  group finsh
    rt-thread/components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group mpu6xxx
    packages/mpu6xxx-latest/src/: mpu6xxx.c sensor_inven_mpu6xxx.c
  group Sensors
    rt-thread/components/drivers/sensors/: sensor.c sensor_cmd.c
  group STM32_HAL
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Utilities
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
