# IAR project CubeMX_Config.ewp, settings and files
configuration CubeMX_Config (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CC ST STM32F411CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CubeMX_Config.hex
  ILINK.IlinkOutputFile: CubeMX_Config.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f411xe.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
